# Keil uVision project Templete.uvprojx, settings and files
target Templete (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Templete
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,__FreeBSD__,DEBUG_BOOT=0,DEBUG_SHELL=0
  c include: .\APP;.\BSP;.\Driver\IIC;.\Driver\FAN;.\Driver\RTC;.\Driver\Lock;.\Driver\Lamp;.\Driver\AS608;.\Driver\SI4432;.\Driver\LF125K;.\Driver\SegLED;.\Driver\USART2;.\Driver\keyboard;.\Driver\BUZZER;.\Driver\PCF8951;.\Driver\TIM\timer;.\Driver\NixieTube;.\Driver\illumination;.\Driver\LCD12864;.\Driver\XFS5152CE;.\Driver\ADC1_DMA;.\Driver\Temperature;.\Driver\Servo_hoder;.\Driver\TIM\PWM_Output;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Protocol;.\Question;.\SYSTEM;.\SYSTEM\fifo;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\WiFiToCloud;.\Driver\EEPROM;.\Driver\IR_Alert
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: main.c Init.c userapp.c app_lib.c app_pwd.c stm32f10x_it.c stm32_config.h ReadMe.txt
  group BSP
    ./BSP/: bsp_flash.c
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drive
    ./Driver/illumination/: ldr.c
    ./Driver/RTC/: rtc.c
    ./Driver/FAN/: fan.c
    ./Driver/ADC1_DMA/: adc.c
    ./Driver/Lock/: lock.c
    ./Driver/Lamp/: lamp.c
    ./Driver/TIM/timer/: timer.c
    ./Driver/Servo_hoder/: servo.c
    ./Driver/LF125K/: lf125k.c
    ./Driver/AS608/: as608.c
    ./Driver/IIC/: hal_iic.c
    ./Driver/Buzzer/: buzzer.c
    ./Driver/PCF8951/: pcf8591.c
    ./Driver/keyboard/: keyboard.c
    ./Driver/XFS5152CE/: xfs5152ce.c
    ./Driver/NixieTube/: nixie_tube.c
    ./Driver/LCD12864/: LCD12864.c
    ./Driver/Temperature/: temperature.c
    ./Driver/TIM/PWM_Output/: pwm_output.c
    ./Driver/SI4432/: si4332a.c si4332b.c
  group Startup
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Question
    ./Question/: queuing_machine.c 2017_A.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/fifo/: kfifo.c
    ./SYSTEM/: debug_printf.h
  group WiFiToCloud
    ./WiFiToCloud/: WiFiToCloud.c CloudReference.h
  group Protocol
    ./Protocol/: NLECloud_TCP.c usart_protocol.c
